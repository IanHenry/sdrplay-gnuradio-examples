options:
  parameters:
    author: Ian Henry, G0LFT
    generate_options: qt_gui
    id: rtty
    output_language: python
    title: SDR Radio
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: freq_khz * 1e3
  states: {}
- name: filename_input
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0, 1, 1, 1
    label: Filename
    type: string
    value: rtty_capture.iq
  states: {}
- name: freq_correction
  id: variable_qtgui_range
  parameters:
    label: Frequency Correction Offset
    start: '-5'
    step: '0.001'
    stop: '5'
    value: '0'
  states: {}
- name: freq_khz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Frequency (kHz)
    type: real
    value: '14090'
  states: {}
- name: record_toggle
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0, 2, 1, 1
    initPressed: 'False'
    label: Capture IQ
    pressBackgroundColor: red
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: file_sink
  id: blocks_file_sink
  parameters:
    file: os.path.join("..", "data", filename_input) if record_toggle == 1 else os.devnull
    type: complex
    unbuffered: 'True'
  states: {}
- name: freq_xlating_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '4'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, 0.3e3, 0.25e3)
    type: ccc
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_plot
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1, 2, 2, 1
    legend: 'False'
    name: SSB IQ Plot
    size: '8192'
    type: complex
    update_time: '0.002'
    xmax: '0.2'
    xmin: '-0.2'
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_freq_plot
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1, 0, 1, 2
    type: complex
  states: {}
- name: qtgui_time_plot
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2, 0, 1, 2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: resampler
  id: rational_resampler_xxx
  parameters:
    decim: '625'
    interp: '480'
    type: fff
  states: {}
- name: sdrplay_source
  id: soapy_sdrplay_source
  parameters:
    agc: 'True'
    agc_setpoint: '-10'
    antenna: A
    center_freq: center_freq
    freq_correction: freq_correction
    gain: '30'
    lna_state: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', resampler, '0']
- [freq_xlating_filter, '0', blocks_complex_to_real_0, '0']
- [freq_xlating_filter, '0', file_sink, '0']
- [freq_xlating_filter, '0', qtgui_const_plot, '0']
- [freq_xlating_filter, '0', qtgui_time_plot, '0']
- [resampler, '0', audio_sink, '0']
- [sdrplay_source, '0', freq_xlating_filter, '0']
- [sdrplay_source, '0', qtgui_freq_plot, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

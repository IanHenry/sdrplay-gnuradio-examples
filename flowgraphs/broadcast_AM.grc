options:
  parameters:
    author: Ian Henry, G0LFT
    generate_options: qt_gui
    id: broadcast_am
    output_language: python
    title: SDR Radio
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: freq_khz * 1e3
  states: {}
- name: filename_input
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0, 1, 1, 1
    label: Filename
    type: string
    value: broadcast_am_capture.iq
  states: {}
- name: freq_khz
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Frequency (kHz)
    type: real
    value: '909'
  states: {}
- name: freqcor
  id: variable_qtgui_range
  parameters:
    label: Frequency Correction Offset
    start: '-5'
    step: '0.001'
    stop: '5'
    value: '0'
  states: {}
- name: record_toggle
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0, 2, 1, 1
    initPressed: 'False'
    label: Capture IQ
    pressBackgroundColor: red
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '3000'
    audio_stop: '5000'
    chan_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: os.path.join("..", "data", filename_input) if record_toggle == 1 else os.devnull
    type: complex
    unbuffered: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate, 15e3, 8e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1, 2, 2, 1
    legend: 'False'
    name: SDR Radio IQ Plot
    size: '8192'
    type: complex
    update_time: '0.002'
    width1: '0'
    xmax: '0.8'
    xmin: '-0.8'
    ymax: '0.8'
    ymin: '-0.8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1, 0, 1, 2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2, 0, 1, 2
    label1: In-Phase (I)
    label2: Quadrature (Q)
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '48'
    type: fff
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    agc: 'True'
    agc_setpoint: '-10'
    antenna: A
    center_freq: center_freq
    freq_correction: freqcor
    gain: '30'
    lna_state: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0_0, '0']
- [soapy_sdrplay_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_sdrplay_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
